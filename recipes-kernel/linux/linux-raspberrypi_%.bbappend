FILESEXTRAPATHS:prepend := "${THISDIR}:"

SRC_URI += "file://i2c-enable.cfg"
