CMDLINE:prepend = "console=serial0,115200 "
